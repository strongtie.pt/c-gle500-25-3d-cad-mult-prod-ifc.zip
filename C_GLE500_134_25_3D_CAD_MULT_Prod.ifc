Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-11-23T13:12:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20140606_1530(x64) - Exporter 2015.0.2014.0606 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Nov 23 13:12:36 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{FC88EA90-6118-4CF7-BFC7-64A06D230CB4}\ifc * Database version: 5507 * Database creation date: Thu Nov 23 13:12:36 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Nov 23 13:12:36 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Nov 23 13:12:36 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 5 - 235 Models\Normal Holes\RFA 3D\C_GLE500_134_25_3D_CAD_MULT_Prod.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no; Type Name: Level 1
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcBuildingElementProxy: C_GLE500_134_25_3D_CAD_MULT_Prod, C_GLE500_134_25_3D_CAD_MULT_Prod:C_GLE500_134_25_3D_CAD_MULT_Prod:213680
In: Level 1
Material: Galvanised
Pset_BuildingElementProxyCommon - Reference: GLE500/134/2.5
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Constraints - Level: Level: Level 1; Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.00392909 ft3
Other - Category: Structural Connections; Family: C_GLE500_134_25_3D_CAD_MULT_Prod: C_GLE500_134_25_3D_CAD_MULT_Prod; Family and Type: C_GLE500_134_25_3D_CAD_MULT_Prod: C_GLE500_134_25_3D_CAD_MULT_Prod; Schedule Level: Level: Level 1; Type: C_GLE500_134_25_3D_CAD_MULT_Prod: C_GLE500_134_25_3D_CAD_MULT_Prod; Type Id: C_GLE500_134_25_3D_CAD_MULT_Prod: C_GLE500_134_25_3D_CAD_MULT_Prod; Family Name: C_GLE500_134_25_3D_CAD_MULT_Prod
Phasing - Phase Created: New Construction
General - Density: 0.819; EPD: https://www.strongtie.eu/eu-EU/EPD; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; Reference: GLE500/134/2.5; Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets
Identity Data - Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Model: GLE500/134/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information; Model ID: 0196646034589058536649026343707215767459; Name: GLE500/134/2.5; ObjectType: GLE500/134/2.5; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; Product Type: Joist hanger; Provide Feedback: mailto:EUdrawings@strongtie.com; Type Name: C_GLE500_134_25_3D_CAD_MULT_Prod; UniClass Number: Pr_20_29_31_44; UniClass Title: Joist hangers; URL: www.strongtie.eu
Materials and Finishes - Product Material: Galvanised
