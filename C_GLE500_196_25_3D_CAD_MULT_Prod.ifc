Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2023-09-27T15:12:31
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20130308_1515(x64) - Exporter 2014.0.2013.0308 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Sep 27 15:12:31 2023 * Host: 105VN450 * Database: C:\Users\TRONNG~1\AppData\Local\Temp\{5539E2D1-DB43-42EC-9D4C-C65BD5AABB11}\ifc * Database version: 5507 * Database creation date: Wed Sep 27 15:12:31 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Sep 27 15:12:31 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Sep 27 15:12:31 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: S:\@Technology\9.BIMCAD EU\2.PROJECTS\ES-234032 BIMCAD EU_Batch 2_1253 models\Working\3D Content\Part 1 - 150 Models\Normal Holes\IFC\GLE500_196_25.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Graphics - Symbol at End 1 Default: no; Symbol at End 2 Default: yes; Line Weight: 1; Color: 0; Line Pattern: -3000010
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm
Identity Data - Structural: no; Building Story: yes; Name: Level 1

# IfcBuildingElementProxy: GLE500_196_25, GLE500_196_25:GLE500_196_25:110695
In: Level 1
Material: Galvanised
Other - Schedule Level: Level: Level 1
Phasing - Phase Created: New Construction
Constraints - Offset: 0 mm; Default Elevation: 0 mm
Dimensions - Volume: 0.0039364 ft3
Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie
Pset_BuildingElementProxyCommon - Reference: GLE500/196/2.5
Identity Data - URL: www.strongtie.eu; Product Type: Joist hanger; ObjectType: GLE500/196/2.5; Model ID: 0195349791934478339734885828438984622716; UniClass Title: Joist hangers; Provide Feedback: mailto:EUdrawings@strongtie.com; Copyright: ©Simpson Strong-Tie; Description: Joist hanger; Manufacturer: Simpson Strong-Tie; Name: GLE500/196/2.5; OmniClass Number: 23.20.40.11.24.14; OmniClass Title: Wood Connectors; UniClass Number: Pr_20_29_31_44; Model: GLE500/196/2.5; Model Disclaimer: Contact Simpson Strong-Tie Company for more information
General - Technical datasheet: https://www.strongtie.eu/eu-EU/technical-data-sheets; ETA / DoP: https://www.strongtie.eu/eu-EU/cemarking; EPD: https://www.strongtie.eu/eu-EU/EPD; Density: 0.88; Reference: GLE500/196/2.5
Materials and Finishes - Product Material: Galvanised
